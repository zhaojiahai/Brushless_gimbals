# Keil uVision project 061_无刷云台.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\HARDWARE\MPU6050;..\QUAD\ANO_DT;..\HARDWARE\TIM3;..\QUAD\TaskRun;..\SYSTEM\time;..\QUAD\AHRS;..\HARDWARE\MOTO;..\HARDWARE\UART4;..\QUAD\Commander;..\SYSTEM\delay;..\HARDWARE\STMFLASH;..\QUAD\Config;..\HARDWARE\PWM;..\QUAD\FastMath;..\QUAD\PID
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MOTO/: moto.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/TIM3/: tim3.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/PWM/: pwm.c
  group QUAD
    ../QUAD/ANO_DT/: ANO_DT.c
    ../QUAD/TaskRun/: taskrun.c
    ../QUAD/AHRS/: ahrs.c
    ../QUAD/Commander/: commander.c
    ../QUAD/Config/: config.c
    ../QUAD/FastMath/: fastmath.c
    ../QUAD/PID/: pid.c
